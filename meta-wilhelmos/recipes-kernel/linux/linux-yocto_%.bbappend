FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://usb-root.cfg file://hardening.cfg"
